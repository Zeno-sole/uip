# Keil uVision project MtdSystem.uvprojx, settings and files
target MtdSystem (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MtdSystem +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_TCS570
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\App;..\User\BSP;..\User\NetDriver;..\User\SpiFlash;..\User\stm32fxxx;..\User\IR\inc;..\Libraries\Third_Party\FatFs\src;..\Libraries\Third_Party\uIP\apps\dhcpc;..\Libraries\Third_Party\uIP\apps\resolv;..\Libraries\Third_Party\uIP\apps\webclient;..\Libraries\Third_Party\uIP\apps\webserver;..\Libraries\Third_Party\uIP\lowlevel;..\Libraries\Third_Party\uIP\uip;..\Libraries\Third_Party\uCOS-II\Config;..\Libraries\Third_Party\uCOS-II\Ports;..\Libraries\Third_Party\uCOS-II\Source;..\Libraries\Third_Party\uCOS-II\uC-CPU;..\Libraries\Third_Party\uCOS-II\uC-LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../User/: main.c
  group app
    ../User/App/: fileopt.h fileopt.c baseins.c baseins.h groupins.c groupins.h app_cfg.h crc16.c crc16.h
  group bsp
    ../User/BSP/: bsp.c bsp.h bsp_uart_printf.c bsp_uart_printf.h bsp_uart_control.c bsp_uart_key.c bsp_uart_key.h bsp_wm8731.h bsp_wm8731.c bsp_calendar.c bsp_date.c bsp_rtc.c bsp_calendar.h bsp_date.h bsp_uart_control.h bsp_rtc.h bsp_input.c bsp_input.h bsp_iis.c bsp_iis.h bsp_timer.c bsp_timer.h bsp_beep.c bsp_beep.h
  group IR
    ../User/IR/src/: Infrared.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group stm32fxxx
    ../User/stm32fxxx/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c
  group SpiFlash
    ../User/SpiFlash/: bsp_spi_flash.c bsp_spi_flash.h
  group FatFs
    ../Libraries/Third_Party/FatFs/src/: diskio.c ff.c
  group NetDriver
    ../User/NetDriver/: lan9220.h lan9220.c
  group uIP
    ../Libraries/Third_Party/uIP/uip/: timer.c uip.c uiplib.c uip_arp.c uipopt.h
  group uIP-LowLevel
    ../Libraries/Third_Party/uIP/lowlevel/: clock-arch.h uip-conf.h clock-arch.c
  group uIP-HttpClient
    ../Libraries/Third_Party/uIP/apps/webclient/: webclient.c webclient.h
  group uIP-DHCP
    ../Libraries/Third_Party/uIP/apps/dhcpc/: dhcpc.h dhcpc.c
  group uCOS-Config
    ../Libraries/Third_Party/uCOS-II/Config/: app_hooks.c cpu_cfg.h lib_cfg.h os_cfg.h
  group uCOS-Ports
    ../Libraries/Third_Party/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uCOS-Source
    ../Libraries/Third_Party/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-CPU
    ../Libraries/Third_Party/uCOS-II/uC-CPU/: cpu_a.asm
